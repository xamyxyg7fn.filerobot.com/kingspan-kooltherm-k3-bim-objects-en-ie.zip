Properties of the parts of a building model (IFC4X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 55f05fe8-a263-46a9-8842-e404949f0f18, NumberOfSaves: 1], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Internal]
File name: 02K3-KSI-XX-ZZ-M3-Z-0001.ifc
Time: 2025-06-27T14:28:03+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Kingspan Kooltherm® K3 Floorboard

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Pset_SpaceCommon - Reference: Project Information; IsExternal: no
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K3 Floorboard; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 0
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no; sets with these values: 2
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K3 Floorboard; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Pset_BuildingStoreyCommon - Reference: Level:Circle Head - Project Datum
Pset_SpaceCommon - IsExternal: no; Reference: Level:Circle Head - Project Datum
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000
